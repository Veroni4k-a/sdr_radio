options:
  parameters:
    author: kupcova_ve
    generate_options: qt_gui
    id: probnik
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '4000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '5865000000'
    gain1: '''slow_attack'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '10000000'
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '44.10000'
    gain: '1'
    interp: '7'
    samp_rate: '10000000'
    type: interp_fir_filter_ccf
    width: '1000000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '""SDR Pluto"'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
